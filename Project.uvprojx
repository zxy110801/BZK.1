# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Start;.\User;.\Library;.\API;.\API\ADC;.\API\Beep;.\API\Delay;.\API\Key;.\API\Key_EXTI;.\API\LED;.\API\PWM;.\API\Systick;.\API\TIM;.\API\TIM8_sr04;.\API\ultrasonic;.\API\USART;.\API\DMA;.\API\sys;.\API\LCD;.\API\I2C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: startup_stm32f10x_hd.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group API
    ./API/ADC/: ADC.c
    ./API/Beep/: Beep.c
    ./API/Delay/: Delay.c
    ./API/Key/: Key.c
    ./API/Key_EXTI/: Key_EXTI.c
    ./API/LED/: LED.c
    ./API/PWM/: PWM.c
    ./API/Systick/: Systick.c
    ./API/TIM/: TIM.c
    ./API/TIM8_sr04/: TIM8_sr04.c
    ./API/ultrasonic/: ultrasonic.c
    ./API/USART/: USART.c
    ./API/DMA/: DMA.c
    ./API/SPI/: SPI.c
    ./API/LCD/: lcd.c lcd_init.c lcdfont.h lcd.h lcd_init.h pic.h
    ./API/sys/: sys.c sys.h
    ./API/I2C/: I2C.c I2C.h AT24C02.c AT24C02.h
